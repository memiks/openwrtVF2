## target/linux/jh71x0/image/Config.in
```kconfig
config JH71X0_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_jh71x0
	default 32
```
